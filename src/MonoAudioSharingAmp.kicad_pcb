# Repository john0312/MonoEarphoneSharingAmp

## KiCad design src/MonoAudioSharingAmp.kicad_pcb

Parts:
C1, C2, C3: C
C4, C5, C6, C7, C8, C9: CAPAPOL
H1, H2, H3, H4: CONN_1
K1, K2, K3, K4: CONN_5
P2: CONN_2X2
P3, P4, P5: CONN_1
R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12: R
RV1, RV2, RV3, RV4, RV5, RV6: POT
U2, U3, U4, U5: DUAL_OPAMP

Connections:
/CENTERED_INPUT: C1.2, C2.2, C3.2, R12.1, U2.5, U3.3
/ChA_IV: R6.2, R7.1, U2.2, U3.6
/ChA_NI: RV1.2, RV2.2, U2.3, U3.5
/ChA_Out: K2.2, K2.5, R7.2, U2.1, U3.7
/ChB_IV: R8.2, R9.1, U4.6, U5.2
/ChB_NI: RV3.2, RV4.2, U4.5, U5.3
/ChB_Out: K3.2, K3.5, R9.2, U4.7, U5.1
/ChC_IV: R10.2, R11.1, U4.2, U5.6
/ChC_NI: RV5.2, RV6.2, U4.3, U5.5
/ChC_Out: K4.2, K4.5, R11.2, U4.1, U5.7
/INPUT: C1.1, C2.1, C3.1, P2.2, P2.4
/INPUT_L: K1.2, P2.1
/INPUT_R: K1.5, P2.3
/Power/Vcc: R2.1, U2.8, U3.8, U4.8, U5.8; also elsewhere on the board
/PreA_IV: R4.2, R5.1, U2.6, U3.2
/PreA_Out: R5.2, RV1.1, RV2.1, RV3.1, RV4.1, RV5.1, RV6.1, U2.7, U3.1
/VGND: C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, P3.1, R2.2, R3.1, R4.1, R6.1, R8.1, R10.1, R12.2, RV1.3, RV2.3, RV3.3, RV4.3, RV5.3, RV6.3
GND: C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, K1.1, K2.1, K3.1, K4.1, P4.1, P5.1, R3.2, U2.4, U3.4, U4.4, U5.4; also elsewhere on the board

Notes on the sheet:
1: GND 2: L 5: R

Parts:
C10, C11, C12, C13, C14, C15, C16, C17, C18, C19: CAPAPOL
J1, J2: CONN_5
P1: CONN_2X2
R1: R
U1: LP5907; MODULE

Connections:
/Power/Filtered_Vcc: P1.1, U1.5 (Vout)
/Power/USB_5V: C10.1, C11.1, C12.1, C13.1, J1.1, J2.1, P1.3, R1.1, U1.1 (Vin)
/Power/Vcc: C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, P1.2, P1.4; also elsewhere on the board
GND: C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, J1.5, J2.5, U1.2 (GND); also elsewhere on the board
unnamed: R1.2, U1.3 (EN)

Board: 2 copper layers, 90.2 x 48.3 mm, 57 parts (0 on the bottom side), 21 nets.

## Commit log

2014-08-02 Schematic draft. Others work in progress.
2014-08-02 Approximately done.
2014-08-02 Added mounting hole. Added text messages. Enlarged the board.
